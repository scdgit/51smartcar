# Keil uVision project 51smartCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51smartCar +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\lcd1602;.\Public;.\App\HCSR04;.\App\smg;.\App\key;.\App\SG90
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c Timer.c
  group App
    ./App/lcd1602/: lcd1602.c
    ./App/HCSR04/: HCSR04.c
    ./App/smg/: smg.c
    ./App/key/: key.c
    ./App/SG90/: SG90.c
